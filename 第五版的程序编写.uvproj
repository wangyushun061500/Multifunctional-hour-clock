# Keil uVision project 第五版的程序编写.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: 第五版的程序编写 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c 74hc164.c lm75a.c dispaly_led.c 15w.h
  group H Group
    ./H Group/: config.h lm75a.h display_led.h 74hc164.h
  group base Group
    ./base Group/: i2c.c i2c.h adc.c adc.h
